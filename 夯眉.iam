# Autodesk Inventor assembly: 본체
## iProperties
Created: 2015-03
Part Number: 본체
Document SubType Name: Assembly
Designer: elite
Author: elite
